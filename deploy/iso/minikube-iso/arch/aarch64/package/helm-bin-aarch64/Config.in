## deploy/iso/minikube-iso/arch/aarch64/package/helm-bin-aarch64/Config.in
```kconfig
config BR2_PACKAGE_HELM_BIN_AARCH64
	bool "helm-bin"
	default y
	depends on BR2_aarch64
```
